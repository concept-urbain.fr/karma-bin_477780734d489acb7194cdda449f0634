Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Karma Corbaille Métal .IFC
Time: 2020-07-01T07:42:50
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: INS-TAFF-M8-1.5-5-A2_Default (6)
In: Default Storey
Material: Inox A2-70

# IfcBeam: KARM-COR-STD-007_Default
In: Default Storey
Material: S 235

# IfcBeam: KARM-COR-STD-TUB-AC-02_Default
In: Default Storey
Material: S 235

# IfcBeam: KARM-COR-STD-TUB-AC-03_Default
In: Default Storey
Material: S 235

# IfcBeam: KARM-COR-STD-TUB-AC-04_Default (2)
In: Default Storey
Material: S 235

# IfcBeam: KARM-COR-STD-TUB-AC-05_Default (2)
In: Default Storey
Material: S 235

# IfcBeam: KARM-COR-STD-TUB-AC-06_Default (2)
In: Default Storey
Material: S 235

# IfcBeam: KARM-COR-STD-TUB-AC-07_Default
In: Default Storey
Material: S 235

# IfcBeam: KARM-COR-STD-TUB-AC-08_Default
In: Default Storey
Material: S 235

# IfcBeam: KARM-COR-STD-TUB-AC-09_Default (2)
In: Default Storey
Material: S 235

# IfcBeam: KARM-COR-STD-TUB-AC-10_Default
In: Default Storey
Material: S 235

# IfcBeam: KARM-COR-STD-TUB-AC-12_Default
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: BASI-COR-2-60-012_Default
In: Default Storey
Material: S235

# IfcBuildingElementProxy: INS-TAFF-M8-1.5-5-A2_Default (42)
In: Default Storey
Material: Inox A2-70

# IfcBuildingElementProxy: KARM-COR-STD-001_Default
In: Default Storey
Material: S 235
PSet_Mass_Property - Mass Measure: 55.5904; Area Measure: 6.39467; Volume Measure: 0.00789325

# IfcBuildingElementProxy: KARM-COR-STD-007_Default
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: KARM-COR-STD-008_Default
In: Default Storey
Material: EN AW 5754

# IfcBuildingElementProxy: KARM-COR-STD-TUB-AC-01_Default (2)
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: KARM-COR-STD-TUB-AC-02_Default
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: KARM-COR-STD-TUB-AC-03_Default
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: KARM-COR-STD-TUB-AC-07_Default
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: KARM-COR-STD-TUB-AC-08_Default
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: KARM-COR-STD-TUB-AC-10_Default
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: KARM-COR-STD-TUB-AC-11_Default (2)
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: KARM-COR-STD-TUB-AC-12_Default
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: SymétrieKARM-COR-STD-007_Default (2)
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: TB embase M6x20 (4)
In: Default Storey
Material: Steel
