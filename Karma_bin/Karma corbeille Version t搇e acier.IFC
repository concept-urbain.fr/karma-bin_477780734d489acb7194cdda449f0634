Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Karma corbeille Version tôle acier.IFC
Time: 2020-07-01T07:41:17
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: KARM-COR-STD-001_Default
In: Default Storey
Material: S 235
PSet_Mass_Property - Mass Measure: 49.095; Area Measure: 5.11663; Volume Measure: 0.00714507

# IfcBeam: SymétrieKARM-COR-STD-TOL-007_Default
In: Default Storey
Material: S 235

# IfcBeam: TB embase M6x20 (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: BASI-COR-2-60-012_Default
In: Default Storey
Material: S235

# IfcBuildingElementProxy: Caoutchouc corbeille_Default
In: Default Storey
Material: Caoutchouc silicone

# IfcBuildingElementProxy: KARM-COR-STD-TOL-007_Default (2)
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: SymétrieKARM-COR-STD-TOL-007_Default
In: Default Storey
Material: S 235

# IfcBuildingElementProxy: TB embase M6x20 (2)
In: Default Storey
Material: Steel
