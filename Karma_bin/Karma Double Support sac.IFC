Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Karma Double Support sac.IFC
Time: 2020-07-01T07:41:59
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: KARM-COR-TRI-BOIS-002_Default
In: Default Storey
Material: Douka

# IfcBeam: KARM-COR-TRI-BOIS-003_Default
In: Default Storey
Material: Douka

# IfcBeam: KARM-COR-TRI-BOIS-004_Default
In: Default Storey
Material: Douka

# IfcBuildingElementProxy: KARM-COR-TRI-BOIS-002_Default
In: Default Storey
Material: Douka

# IfcBuildingElementProxy: KARM-COR-TRI-BOIS-003_Default
In: Default Storey
Material: Douka

# IfcBuildingElementProxy: KARM-COR-TRI-BOIS-004_Default
In: Default Storey
Material: Douka

# IfcBuildingElementProxy: KARM-COR-TRI-VIGI-005_Default
In: Default Storey
PSet_Mass_Property - Mass Measure: 42.0131; Area Measure: 3.47918; Volume Measure: 0.0105811
