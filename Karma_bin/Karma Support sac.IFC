Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Karma Support sac.IFC
Time: 2020-05-05T09:41:13
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: FHC M12x30 A2_Default
In: Default Storey
Material: 0

# IfcBeam: KARM-COR-STD-001_Default
In: Default Storey
Material: 0

# IfcBeam: KARM-COR-STD-004_Default (2)
In: Default Storey
Material: 0

# IfcBeam: KARM-COR-STD-BOIS-01_Default
In: Default Storey
Material: Douka

# IfcBeam: KARM-COR-STD-BOIS-02_Default (2)
In: Default Storey
Material: Douka

# IfcBeam: KARM-COR-STD-BOIS-03_Default
In: Default Storey
Material: Douka

# IfcBeam: KARM-COR-VIGI-008_Default (2)
In: Default Storey
Material: 0

# IfcBeam: KARM-COR-VIGI-009_Default
In: Default Storey
Material: 0

# IfcBeam: KARM-COR-VIGI-IMMO-017_Default
In: Default Storey
Material: 0

# IfcBeam: MULT-COR-002_Default
In: Default Storey
Material: 0

# IfcBeam: MULT-COR-CHA-003-A_Default (2)
In: Default Storey
Material: 0

# IfcBeam: SymétrieKARM-COR-VIGI-008_Default (2)
In: Default Storey
Material: 0

# IfcBeam: TB embase M6x20 (2)
In: Default Storey
Material: Steel

# IfcBeam: VEMO-995G-M12x60-EV_M 12
In: Default Storey
Material: 0

# IfcBuildingElementProxy: BASI-COR-2-60-012_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Caoutchouc corbeille_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Caoutchouc silicone

# IfcBuildingElementProxy: EURO-LOCKS-F248D-S341439-2_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: FHC M12x30 A2_Default (3)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: KARM-COR-STD-002_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: KARM-COR-STD-BOIS-03_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Douka

# IfcBuildingElementProxy: KARM-COR-VIGI-BOIS-001_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: Douka

# IfcBuildingElementProxy: MULT-COR-CHA-002-B_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: MULT-COR-CHA-004-A_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Sol corbeille_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Béton

# IfcBuildingElementProxy: TB embase M6x20 (2)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: VEMO-995G-M12x60-EV_M 12 (3)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcRamp: KARM-COR-STD-BOIS-01_Default
In: Default Storey
Material: Douka

# IfcShadingDevice: MULT-COR-CHA-004-A_Default
In: Default Storey
Material: 0
